# Keil uVision project FATFS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FATFS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o ..\OBJ\FATFS.bin ..\OBJ\FATFS.axf
  c flags: OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\SD;..\MALLOC;..\USMART;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE;..\STM32F10x_FWLib;..\sim808;..\HARDWARE\EXTI;..\HARDWARE\ADC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/FLASH/: flash.c
    ./: usart2.c gps.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/ADC/: adc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_adc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group README
    ../: README.TXT
  group SIM808
    ../sim808/: sim808.c sim808.h
